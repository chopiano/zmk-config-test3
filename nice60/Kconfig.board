## nice60/Kconfig.board
```kconfig
# Copyright (c) 2021 Nick Winans
# SPDX-License-Identifier: MIT

config BOARD_NICE60
    bool "nrf_poker64"
    depends on SOC_NRF52840_QIAA
```
